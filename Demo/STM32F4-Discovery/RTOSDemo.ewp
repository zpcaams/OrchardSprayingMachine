# IAR project RTOSDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; board\; User\; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM4F; ..\Common\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ; board\; Libraries\CMSIS\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: FreeRTOSConfig.h main.c ParTest.c readme.txt stm32f4xx_it.c
  group Common Demo Source
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c flash.c GenQTest.c integer.c PollQ.c recmutex.c semtest.c sp_flop.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/Portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group ST_and_IAR_code/board
    board/: stm32f4_discovery.c
  group ST_and_IAR_code/startup
    startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group ST_and_IAR_code/STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group User
    User/: osm_adc.c osm_ctrl.c osm_gpo.c osm_usart.c
